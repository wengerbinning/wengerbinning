## c/Kconfig
```kconfig
config HELLO_WORLD
    bool "Hello Wrold"
    help 
    This is C hello world.
    
```
